FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Set-wifi_module-to-brcm-since-that-s-what-I-have.patch"
