KERNEL_MODULE_AUTOLOAD += "bcmdhd"