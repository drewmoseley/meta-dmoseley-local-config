FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " \
    file://0001-Add-demo-module-for-ipk-package-updates.patch \
"
