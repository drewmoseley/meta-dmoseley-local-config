PACKAGECONFIG_remove_rpi = "dc1394"