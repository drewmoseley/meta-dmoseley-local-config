MENDER_DEMO_HOST_IP_ADDRESS = "192.168.7.36"
MENDER_DEMO_HOST_IP_ADDRESS_vexpress-qemu = ""
MENDER_DEMO_HOST_IP_ADDRESS_vexpress-qemu-flash = ""
