VOLATILE_BINDS:append:dmoseley-updater-mender = "\
    /data/root      /home/root\n\
"
VOLATILE_BINDS:append:dmoseley-updater-swupdate = "\
    /media/root      /home/root\n\
"
