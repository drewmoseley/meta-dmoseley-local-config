FILESEXTRAPATHS_prepend_colibri-imx7-nand := "${THISDIR}/files:"
