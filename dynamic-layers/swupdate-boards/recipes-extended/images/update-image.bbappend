FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SWUPDATE_IMAGES_FSTYPES[core-image-full-cmdline] = ".ext4.zck.zckheader"
