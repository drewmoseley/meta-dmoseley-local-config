require u-boot-common-dmoseley.inc
require recipes-bsp/u-boot/u-boot-tools.inc

COMPATIBLE_MACHINE = "(raspberrypi4|raspberrypi4-64)"

