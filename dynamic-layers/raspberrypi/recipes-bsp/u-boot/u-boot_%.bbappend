require u-boot-common-dmoseley.inc
