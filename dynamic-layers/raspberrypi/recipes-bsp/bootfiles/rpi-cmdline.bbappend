CMDLINE:append = " net.ifnames=0 "
