PACKAGECONFIG:remove:rpi = "dc1394"