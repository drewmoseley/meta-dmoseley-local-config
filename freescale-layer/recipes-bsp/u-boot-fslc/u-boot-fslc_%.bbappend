FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_imx7dsabresd = " file://0001-Enable-PXE-for-imx7dsabresd.patch"
