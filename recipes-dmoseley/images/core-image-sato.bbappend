require core-image-graphical.inc
IMAGE_INSTALL:append = " chromium-x11 "
