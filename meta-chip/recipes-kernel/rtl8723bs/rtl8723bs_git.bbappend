FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " file://0001-rtl8723bs-hide-nolinked-power-save-info-when-not-deb.patch"

