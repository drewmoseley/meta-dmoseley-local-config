require recipes-bsp/u-boot/u-boot_dmoseley.inc
