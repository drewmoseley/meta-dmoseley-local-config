require mender-dmoseley.inc
