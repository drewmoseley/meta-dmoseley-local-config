XSERVER_RRECOMMENDS_remove_rpi = " xf86-input-libinput "
XSERVER_RRECOMMENDS_append_rpi = " xf86-input-evdev "
