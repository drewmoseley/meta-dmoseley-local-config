require go-dmoseley.inc
